SUMMARY = "Bootlinlabs games"
PR = "r1"


LICENSE = "MIT"

inherit packagegroup

RDEPENDS:${PN} = "ctris"